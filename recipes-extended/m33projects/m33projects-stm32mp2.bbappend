FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
# Configure recipe for CubeMX
inherit cubemx-stm32mp
