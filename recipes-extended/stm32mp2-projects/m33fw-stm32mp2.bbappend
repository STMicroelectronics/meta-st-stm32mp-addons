# Configure recipe for CubeMX
inherit cubemx-stm32mp
